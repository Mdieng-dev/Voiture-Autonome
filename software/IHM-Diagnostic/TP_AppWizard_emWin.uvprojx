# Keil uVision project TP_AppWizard_emWin.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: TP_AppWizard_emWin
  BeforeMake: "U:\_S4_Projet\CAN_Sprint2_marche - Copie\TP_AppWizard_emWin\appwizard\generate_gui_all.bat"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Main + Threads
    ./: main.c GUI_SingleThread.c
  group Overclock for LCD with RAM
    ./: configuration.c
  group Source AppWizard
    appwizard/Source/: APPW_MainTask.c
    appwizard/Source/Generated/: Resource.c APPWConf.c ID_SCREEN_intro.c SCREEN_Conduite.c SCREEN_Diagnostic.c SCREEN_Detection.c
    appwizard/Source/CustomCode/: ID_SCREEN_intro_Slots.c SCREEN_Conduite_Slots.c SCREEN_Diagnostic_Slots.c SCREEN_Detection_Slots.c
  group Resource AppWizard
    appwizard/Resource/Image/: hello_mod.c home_touch.c drive_touch.c detect_touch.c diag_touch.c clign_gauche_on.c clign_gauche_off.c clign_droit_on.c clign_droit_off.c Phare_on.c Phare_off.c ANALOG_Button_Up_50px50.c ANALOG_Button_Down_50px50.c gestionadapte.c DARK_Progbar_Tile_H_Blue_1x16.c DARK_Progbar_Tile_H_Gray_1x16.c DARK_Slider_Shaft_H_Left_Blue_30x16.c DARK_Slider_Shaft_H_Right_Gray_30x16.c DARK_Slider_Thumb_Up_22x22.c DARK_Slider_Thumb_Down_22x22.c DARK_Switch_Body_H_On_55x20.c DARK_Switch_Body_H_Off_55x20.c DARK_Switch_Thumb_26x26.c panneau.c Pan_stop.c Voiture.c show_fine0.c unlock.c unlock_icone.c o_red_face.c o_orange_face.c o_green_face.c o_red_dos.c o_orange_dos.c o_green_dos.c
    appwizard/Resource/Font/: Roboto_24_Normal_EXT_AA4.c Roboto_32_Normal_EXT_AA4.c Roboto_16_Normal_EXT_AA4.c
    appwizard/Resource/Text/: APPW_Language_0.c APPW_Pattern.c
  group AppWizard Config
    appwizard/: APPW_X_FS.c
software components: CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Drivers:Touch Screen 1.1.1, Board Support:Touchscreen 1.1.1, Board Support:emWin LCD 1.1.1, CMSIS Driver:CAN 1.15.0, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA2D 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:I2C 1.3.0, Device:STM32Cube HAL:LTDC 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SDRAM 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:Startup 1.2.5, Graphics Display:STM32F746G-Discovery 1.0.2, Graphics:CORE 6.32.3, Graphics:Input Device:Touchscreen 6.32.3
